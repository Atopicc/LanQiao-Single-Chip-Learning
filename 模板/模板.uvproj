# Keil uVision project 模板.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 模板 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\keil\KeilC51\C51\INC\STC
  group Source Group 1
    ./: main.c ds1302.c iic.c onewire.c seg.c kbd.c sonic.c uart.c frequence.c PWM.c
